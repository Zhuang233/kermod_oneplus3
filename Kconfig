## Kconfig
```kconfig
config HELLO
    tristate "Kernel Hack Driver"
    default m
    help
    This is the kernel hack driver for android system.
```
